options:
  parameters:
    author: Enzo BECAMEL F4IAI
    description: Decodeur pour satellite NOAA utilisant les logiciels sdr4space.light et GNURadio Companion
    generate_options: no_gui
    id: decodeur_NOAA_WAV
    output_language: python
    run_options: run
    title: Decodeur NOAA sdr4space GNU Radio WAV
  states: {}

blocks:
- name: name_record
  id: variable_config
  parameters:
    config_file: /home/enzo/Documents/GNURadio/decodeur_NOAA/sdr4space_multi/last_record.ini
    option: key
    section: main
    type: string
    value: '"record"'
    writeback: None
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"/home/enzo/Documents/GNURadio/decodeur_NOAA/sdr4space_multi/" + name_record'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/enzo/Documents/GNURadio/decodeur_NOAA/record.wav
    samp_rate: samp_rate
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_file_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
